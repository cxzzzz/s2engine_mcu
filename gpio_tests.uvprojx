# Keil uVision project gpio_tests.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: gpio_tests
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output gpio_tests.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o gpio_tests.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORTEX_M3
  c include: ..\..\..\..\software\cmsis\CMSIS\Include; ..\..\..\..\software\cmsis\Device\ARM\CM3DS\Include; ..\..\..\..\software\common\retarget; ..\..\testcodes\generic
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Source/src/: init.c startup_CM3DS.s
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: CM3DS_MPS2_driver.c
  group Application
    ./Source/src/: defs.c dma.c int_handler.c main.c net.c s2chip.c
    ./Source/src/test/: dma_test.c reg_test.c wm_test.c fm_test.c pe_test.c ppu_test.c net_test.c sdram_test.c basic_test.c nms_test.c pad_power_test.c fpga_basic_test.c
    ./: ofifo_test.c
  group System
    ../../../../software/common/retarget/: uart_stdout.c retarget.c
    ../../../../software/cmsis/Device/ARM/CM3DS/Source/: system_CM3DS.c
target mps2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: gpio_tst
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 FPGA_IMAGE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
